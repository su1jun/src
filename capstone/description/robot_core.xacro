Commit message: 1

File: capstone/description/robot_core.xacro (robot description, xacro)
@@ -73,5 +73,5 @@
     </link>
     <gazebo reference="chassis">
-        <material>Gazebo/Grean</material>
+        <material>Gazebo/Teal</material>
     </gazebo>
     <!-- LEFT WHEEL LINK -->
